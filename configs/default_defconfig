## configs/default_defconfig
```kconfig
# CONFIG_DC_SIM_SDB is not set
# CONFIG_DC_SIM_WAVE is not set
# CONFIG_DC_SIM_NVBOARD is not set
# CONFIG_DC_SIM_DIFFTEST is not set
```
